# Keil uVision project G474_FOC.uvprojx, settings and files
target G474_FOC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G474_FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../MDK-ARM/USER;../MDK-ARM/USER/Utility;../MDK-ARM/USER/Main;./DSP_Lib;./DSP_Lib/Include;../MDK-ARM/USER/System;../MDK-ARM/USER/Peripheral;../MDK-ARM/USER/Algorithm;../MDK-ARM/USER/Library
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Main
    ./USER/Main/: Foc_Comm.c Foc_Control.c Foc_Error.c Init_music.c
  group Utility
    ./USER/Utility/: util_adc.c util_fdcan.c util_gpio.c util_pwm.c util_spi.c
  group Configure
    ./USER/: configure.h
  group DSP_Lib
    ./DSP_Lib/: arm_cortexM4lf_math.lib
  group System
    ./USER/System/: sys_dwt.c
  group Peripheral
    ./USER/Peripheral/: drv8323_util.c mt6825_spi.c
  group Algorithm
    ./USER/Algorithm/: alg_kf.c alg_pid.c alg_qekf.c alg_swf.c
  group Library
    ./USER/Library/: lib_buff.c lib_crc.c lib_filter.c lib_math.c
software components: CMSIS:CORE 4.3.0
